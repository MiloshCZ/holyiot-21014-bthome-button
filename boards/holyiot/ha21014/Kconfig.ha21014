## boards/holyiot/ha21014/board.yml
```yaml
board:
  name: ha21014
  full_name: HOLYIOT 21014 BTHome Button
  vendor: holyiot
  socs:
    - name: nrf52810
```
